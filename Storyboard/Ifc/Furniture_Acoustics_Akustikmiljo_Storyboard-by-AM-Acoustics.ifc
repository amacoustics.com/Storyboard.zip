Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Furniture_Acoustics_Akustikmiljo_Storyboard-by-AM-Acoustics.ifc
Time: 2020-01-15T09:36:14
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: Storyboard by AM Acoustics
ePset_BIMobjectScript - Bracket: With; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Storyboard by AM Acoustics; SKU (BO_prodsku): storyboard; ManufacturName (BO_Manufac): Akustikmiljö; ProductFamily (BO_prodfam): Furniture; ProductGroup (BO_prodgroup): Wall and Ceiling Acoustics; ManufacturCountry (BO_mancont): Sweden; DesignCountry (BO_designcont): Sweden; EditionNumber (BO_edinum): 1; Width (BO_width): 1600; Height (BO_height): 1200; Depth (BO_depth): 0; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/akustikmiljo/product/storyboard; ProductDataUrl (BO_prodaturl): bimobject.com/akustikmiljo/product/storyboard; ProductUrl (BO_producturl): https://www.gotessons.com/en/whiteboard-notice-board/storyboard-ecosund; ProductCertification (BO_prodcert): https://www.gotessons.com/en/quality-and-environment/; TechnicalDescription (BO_techcert): https://www.gotessons.com/storage/CC1E4317F52B38445CB44DE2C748DD0EEDD01F4B287B9C841C4DE6151AD48F8F/f5e01fe3591645e9a8af588079334291/pdf/media/432f6d69bcb048d0ab6b61349e35b00a/125600-_ritning.pdf; MaterialMain (BO_mainmat): Polyester; MaterialSecondary (BO_secmat): Polyester; BimObjectMainCategory (BO_bomaincat): Furniture; BimObjectMainCategoryCode (BO_bomaincat_code): furniture; BimObjectCategory (BO_bocat): Acoustics; BimObjectCategoryCode (BO_bocat_code): furniture-acoustics; IfcClassification (BO_ifcclas): Furniture; UnspcCode (BO_unspc): 56; Uniclass2015Code (BO_uniclass2015_code): EF_40_30; Uniclass2015Description (BO_uniclass2015_desc): Furnishings; UniFormat2Code (BO_uniformat2_code): E20; UniFormat2Description (BO_uniformat2_name): FURNISHINGS; RegionEurope (BO_europe): SE
